# Keil uVision project lpc4322_bl.uvproj, settings and files
target lpc4322_bl (ARM-ADS)
  device: LPC4322:Cortex-M4 NXP
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x4000) IROM(0x1A000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpc4322_bl
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1
  c define: DAPLINK_VERSION=251, MSC_ENDPOINT, DAPLINK_BL, DAPLINK_BUILD_KEY=0x9B939D93, INTERFACE_LPC4322, CORE_M4, INTERNAL_FLASH, DAPLINK_HIC_ID=0x97969905
  c misc: --gnu --c99
  c include: ..\..\..\source\usb; ..\..\..\source\daplink; ..\..\..\source\daplink\bootloader; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\settings; ..\..\..\source\rtos; ..\..\..\source\hic_hal\nxp\lpc4322
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=251,-DMSC_ENDPOINT,-DDAPLINK_BL,-DDAPLINK_BUILD_KEY=0x9B939D93,-DINTERFACE_LPC4322,-DCORE_M4,-DINTERNAL_FLASH,-DDAPLINK_HIC_ID=0x97969905
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_BL" --predefine="-I..\..\..\source\hic_hal\nxp\lpc4322"
  group board
    ../../../source/board/: lpc4322_bl.c
  group daplink_bl
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c RTX_Config.c sdk_stub.c util.c validation.c
    ../../../source/daplink/bootloader/: daplink.c main.c SVC_Table.s
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h flash_map.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h serial_flash.h spi.h target_config.h target_reset.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/hic_hal/nxp/lpc4322/: DAP_config.h DAP_config.h daplink_addr.h daplink_addr.h fpu_enable.h fpu_enable.h IO_Config.h IO_Config.h LPC43xx.h LPC43xx.h lpc43xx_cgu.h lpc43xx_cgu.h lpc43xx_scu.h lpc43xx_scu.h lpc_types.h lpc_types.h system_LPC43xx.h system_LPC43xx.h usb_buf.h usb_buf.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/daplink/bootloader/: main.h
    ../../../source/usb/: rl_usb.h usb.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/rtos/: rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/daplink/settings/: settings.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group hic_hal
    ../../../source/hic_hal/nxp/lpc4322/: board_LPC43xx.c board_LPC43xx.c flash.c flash.c fpu_enable.c fpu_enable.c gpio.c gpio.c lpc43xx_cgu.c lpc43xx_cgu.c lpc43xx_scu.c lpc43xx_scu.c read_uid.c read_uid.c system_LPC43xx.c system_LPC43xx.c uart.c uart.c usb_config.c usb_config.c usbd_LPC43xx_USB0.c usbd_LPC43xx_USB0.c
    ../../../source/hic_hal/nxp/lpc4322/armcc/: startup_LPC43xx.s
  group rtos
    ../../../source/rtos/cm3/: HAL_CM3.c
    ../../../source/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom_stub.c
  group usb
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
