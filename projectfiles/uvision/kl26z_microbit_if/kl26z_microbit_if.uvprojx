# Keil uVision project kl26z_microbit_if.uvprojx, settings and files
target kl26z_microbit_if (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MKL26Z128VFM4 NXP
  pack: NXP.MKL26Z4_DFP.10.0.3
  cpu: IRAM(0x1ffff000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl26z_microbit_if +hex
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=251, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, INTERFACE_KL26Z, CPU_MKL26Z128VLH4, DAPLINK_HIC_ID=0x97969901, FLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0, FLASH_DRIVER_IS_FLASH_RESIDENT=1, DAPLINK_NO_ASSERT_FILENAMES, HID_LED_DEF=GPIO_LED_ON, CDC_LED_DEF=GPIO_LED_ON, MSC_LED_DEF=GPIO_LED_ON, USB_PROD_STR="BBC micro:bit CMSIS-DAP"
  c misc: --gnu --c99
  c include: ..\..\..\source\usb; ..\..\..\source\daplink\cmsis-dap; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\usb2uart; ..\..\..\source\daplink\settings; ..\..\..\source\daplink; ..\..\..\source\daplink\interface; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\rtos; ..\..\..\source\hic_hal\freescale\kl26z; ..\..\..\source\hic_hal\freescale\kl26z\MKL26Z4; ..\..\..\projectfiles\uvision\kl26z_bl
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=251,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DINTERFACE_KL26Z,-DCPU_MKL26Z128VLH4,-DDAPLINK_HIC_ID=0x97969901,-DFLASH_SSD_CONFIG_ENABLE_FLEXNVM_SUPPORT=0,-DFLASH_DRIVER_IS_FLASH_RESIDENT=1,-DDAPLINK_NO_ASSERT_FILENAMES,-DHID_LED_DEF=GPIO_LED_ON,-DCDC_LED_DEF=GPIO_LED_ON,-DMSC_LED_DEF=GPIO_LED_ON,-DUSB_PROD_STR="BBC micro:bit CMSIS-DAP"
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\source\hic_hal\freescale\kl26z"
  group board
    ../../../source/board/: microbit.c
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c usbd_user_hid.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c daplink.c main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c RTX_Config.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h flash_map.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h spi.h target_config.h target_reset.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/daplink/cmsis-dap/: DAP.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/freescale/kl26z/: DAP_config.h daplink_addr.h IO_Config.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/hic_hal/freescale/kl26z/MKL26Z4/: fsl_device_registers.h MKL26Z4.h MKL26Z4_features.h system_MKL26Z4.h
    ../../../source/daplink/interface/: main.h swd_host.h tasks.h
    ../../../source/usb/: rl_usb.h usb.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/rtos/: rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/daplink/settings/: settings.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c vfs_nvm.c selectr.c
  group fsl_flash_driver
    ../../../source/hic_hal/freescale/iap/: FlashDev.c FlashPrg.c fsl_flash.c
  group hic_hal
    ../../../source/hic_hal/freescale/kl26z/: flash_map.c gpio.c read_uid.c spi.c uart.c usb_config.c
    ../../../source/hic_hal/freescale/kl26z/armcc/: startup_MKL26Z4.s
    ../../../source/hic_hal/freescale/kl26z/MKL26Z4/: system_MKL26Z4.c
    ../../../source/hic_hal/freescale/: usbd_kinetis.c
    ../../../source/hic_hal/: IS25LP128F.c
  group rtos
    ../../../source/rtos/cm0/: HAL_CM1.c
    ../../../source/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/nordic/nrf51822/: target_16.c
    ../../../source/target/nordic/: target_reset.c
  group usb
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
software components: CMSIS:CORE 5.2.0
