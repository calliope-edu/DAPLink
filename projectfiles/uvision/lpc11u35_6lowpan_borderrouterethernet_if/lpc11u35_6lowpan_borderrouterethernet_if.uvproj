# Keil uVision project lpc11u35_6lowpan_borderrouterethernet_if.uvproj, settings and files
target lpc11u35_6lowpan_borderrouterethernet_if (ARM-ADS)
  device: LPC11U35/501 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_6lowpan_borderrouterethernet_if
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1
  c define: DAPLINK_VERSION=251, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, INTERFACE_LPC11U35, DAPLINK_HIC_ID=0x97969902, IO_CONFIG_OVERRIDE
  c misc: --gnu --c99
  c include: ..\..\..\source\usb; ..\..\..\source\daplink\cmsis-dap; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\usb2uart; ..\..\..\source\daplink\settings; ..\..\..\source\daplink; ..\..\..\source\daplink\interface; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\rtos; ..\..\..\source\hic_hal\nxp\lpc11u35; ..\..\..\source\board\override_lpc11u35_6LoWPAN_BorderRouter
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=251,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DINTERFACE_LPC11U35,-DDAPLINK_HIC_ID=0x97969902,-DIO_CONFIG_OVERRIDE
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\source\hic_hal\nxp\lpc11u35"
  group board
    ../../../source/board/: 6LoWPAN_BorderRouterETHERNET.c
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c usbd_user_hid.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c daplink.c main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c RTX_Config.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h flash_map.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h serial_flash.h spi.h target_config.h target_reset.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/daplink/cmsis-dap/: DAP.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/nxp/lpc11u35/: DAP_config.h DAP_config.h daplink_addr.h daplink_addr.h iap.h iap.h IO_Config.h IO_Config.h LPC11Uxx.h LPC11Uxx.h system_LPC11Uxx.h system_LPC11Uxx.h usb_buf.h usb_buf.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/board/override_lpc11u35_6LoWPAN_BorderRouter/: IO_Config_Override.h
    ../../../source/daplink/interface/: main.h swd_host.h tasks.h
    ../../../source/usb/: rl_usb.h usb.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/rtos/: rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/daplink/settings/: settings.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group hic_hal
    ../../../source/hic_hal/nxp/lpc11u35/: flash.c flash.c gpio.c gpio.c iap.c iap.c read_uid.c read_uid.c system_LPC11Uxx.c system_LPC11Uxx.c uart.c uart.c usb_config.c usb_config.c usbd_LPC11Uxx.c usbd_LPC11Uxx.c
    ../../../source/hic_hal/nxp/lpc11u35/armcc/: startup_LPC11Uxx.s
  group rtos
    ../../../source/rtos/cm0/: HAL_CM1.c
    ../../../source/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/freescale/k64f/: target.c
    ../../../source/target/freescale/: target_reset_Kseries.c
  group usb
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
